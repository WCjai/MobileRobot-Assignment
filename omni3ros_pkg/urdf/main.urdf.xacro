Commit message: Update main.urdf.xacro

File: omni3ros_pkg/urdf/main.urdf.xacro (robot description, xacro)
@@ -61,5 +61,5 @@
 		<parent link="base_link" />
 		<child link="wc_link" />
-		<origin xyz="0.004 0 0"/>
+		<origin xyz="0.005 0 0"/>
 	</joint>
 	<xacro:rim_macro
